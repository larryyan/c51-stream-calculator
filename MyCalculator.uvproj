# Keil uVision project MyCalculator.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: MyCalculator +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Middleware/: Common.h Double2Str.c Double2Str.h Lexer.c Lexer.h Parser.c Parser.h
    ./Drivers/: Buzzer.c Buzzer.h Delay.c Delay.h HappyBrithday.c HappyBrithday.h IndependentKey.c IndependentKey.h LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h Timer1.c Timer1.h
    ./: main.c
